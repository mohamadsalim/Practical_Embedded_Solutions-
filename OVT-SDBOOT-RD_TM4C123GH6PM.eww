<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\App_Image\APP_Image_TM4C123.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Bootloader\BootLoader_TM4C123.ewp</path>
    </project>
    <batchBuild />
</workspace>
